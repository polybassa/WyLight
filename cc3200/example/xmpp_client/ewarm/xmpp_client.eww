<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\lib\ewarm\libxmpp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\xmpp_client.ewp</path>
  </project>
  <batchBuild/>
</workspace>


