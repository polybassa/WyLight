# IAR project provisioning_ap.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; NOTERM
  ICCARM.CCIncludePath2: $..\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\common\; ..\..\..\simplelink\; ..\..\..\simplelink\Include\; ..\..\..\simplelink\Source\; ..\..\..\oslib\; ..\..\..\third_party\FreeRTOS\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: provisioning_ap.bin
  ILINK.IlinkOutputFile: provisioning_ap.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\..\..\simplelink\ewarm\OS\Exe\simplelink.a; ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\oslib\ewarm\free_rtos\Exe\free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
    ../../common/: startup_ewarm.c
