# IAR project serial_wifi.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\common\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\source; ..\..\..\simplelink\include; ..\..\..\oslib\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: serial_wifi.bin
  ILINK.IlinkOutputFile: serial_wifi.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\..\..\simplelink\ewarm\OS\Exe\simplelink.a; ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\oslib\ewarm\free_rtos\Exe\free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: conversions.c main.c pinmux.c serial_wifi.c uart_config.c
    ../../common/: network_if.c startup_ewarm.c uart_if.c
